<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DotmatrixCubeMx_V1_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
